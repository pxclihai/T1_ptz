# Keil uVision project T1-ptz.uvprojx, settings and files
target stm32f103xE (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EasyFlash
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_FULL_ASSERT
  c include: ..\app\inc;..\components\rtt_uart;..\components\others;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS_RVMDK\CM3\CoreSupport;..\Libraries\CMSIS_RVMDK\CM3\DeviceSupport\ST\STM32F10x;..\RT-Thread-1.2.2\include;..\RT-Thread-1.2.2\components\drivers\include;..\RT-Thread-1.2.2\components\drivers\include\drivers;..\RT-Thread-1.2.2\components\finsh;..\components\easyflash\inc;..\..\..\..\workspace;..\easyflash\inc;..\easyflash\src;..\easyflash
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --keep __fsym_*
  group app
    ../APP/src/: app.c app_task.c stm32f10x_it.c
    ../app/src/: user_finsh_cmd.c ptz.c shell_cmd.c
    ../APP/inc/: delay_conf.h stm32f10x_conf.h rtconfig.h
  group bsp
    ../components/others/: bsp.c utils.c
    ../components/rtt_uart/: usart.c
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../Libraries/CMSIS_RVMDK/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group easyflash
    ../components/easyflash/port/: ef_port.c
    ../easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
  group std_periph_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../Libraries/CMSIS_RVMDK/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS_RVMDK/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group rt_thread_kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rt_thread_drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c wrokqueue.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
  group rt_thread_finsh
    ../RT-Thread-1.2.2/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
